Commit message: Data collection

File: src/jaco_urdf.urdf (robot description, URDF)
Before this commit: robot jaco_arm, 10 links, 9 joints
Joints:
- joint j2s7s300_ee_gripper: origin xyz=0.13 0 0 -> xyz=1.5 0 0
